File: dB_KiCad/mcu.kicad_sch (KiCad schematic)
At the start: 11 parts

Commit message: buck converter
Parts:
- added J?: USB_B_Micro, symbol Connector:USB_B_Micro
